# Keil uVision project project name.uvproj, settings and files
target <project name> (MCS-51)
  device: SC95F8617 SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0xFFF) CLOCK(32000000)
  output: project name +hex
  c flags: Optimize=8
  c define: SC95F8x1xB
  c include: ..\FWLib\SC95F_Lib\inc;..\User
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c SC_Init.c SC_it.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c
  group FWLib
    ../FWLib/SC95F_Lib/src/: sc95f_gpio.c sc95f_option.c
  group Startup
    ./: STARTUP.A51
