# Keil uVision project BOOTLOAD.uvproj, settings and files
target <BOOTLOAD> (MCS-51)
  device: SC95F8617B SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0xFFF) CLOCK(32000000)
  output: BOOTLOAD +hex
  c flags: Optimize=8
  c define: SC95F8x1xB
  c include: ..\FWLib\SC95F_Lib\inc;..\User;..\IOT_DRIVER\XIAOMI;..\Drivers
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c SC_Init.c SC_it.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c
  group IOT_DRIVER
    ../IOT_DRIVER/XIAOMI/: CR_util.c MIIO_OPERATE.C
  group Drivers
    ../Drivers/OTADriver/C/: InterruptVectors_OTA.A51 OTADriver_IAP.c OTADriver.c Decrypt_TEA.c Date.c BootLoad_UpdataFlagFill.c
  group FWLib
    ../FWLib/SC95F_Lib/src/: sc95f_timer0.c SC95FXX1XB_IAP_L_lib_V1.3.0.LIB sc95f_iap.c sc95f_uart0.c sc95f_gpio.c sc95f_option.c
  group Startup
    ./: STARTUP.A51
